# Autodesk Inventor assembly: 520143_AC-SCM7U
## iProperties
Created: 2011-05
Part Number: 520143_AC-SCM7U
Document SubType Name: Assembly
Designer: seisen
Author: seisen
